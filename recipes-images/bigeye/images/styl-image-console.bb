DESCRIPTION = "Builds an STYL image  with console environment - no GUI interface."
LICENSE = "MIT"

require recipes-fsl/images/fsl-image-machine-test.bb
require recipes-images/bigeye/images/styl-image-minimal.bb
