require styl-image-fb.inc

