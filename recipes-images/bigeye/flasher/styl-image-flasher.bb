require recipes-images/bigeye/flasher/styl-image-flasher.inc
