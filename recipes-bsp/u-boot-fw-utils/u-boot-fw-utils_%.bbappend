FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://Completed-support-Bigeye-board-for-SWUpdate.patch"
