DESCRIPTION = "STYL Solutions Image"
LICENSE = "MIT"

require recipes-fsl/images/fsl-image-validation-imx.bb
require recipes-images/bigeye/images/styl-image-fb.bb
require recipes-images/bigeye/images/styl-image-remove.bb
