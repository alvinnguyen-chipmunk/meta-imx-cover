FILESEXTRAPATHS_append := "${THISDIR}/${PN}_${PV}"

SRC_URI += "file://0001-Completed-support-Bigeye-gateway-board.patch"
